# IAR project Backup of V3.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: V3.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: V3.hex
  ILINK.IlinkOutputFile: V3.out
  group (top)
    ./: define.h dinind.c dinind.h main.c znggen.h
