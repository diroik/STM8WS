# IAR project MKADD_OUT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x80
  ICCSTM8.CCIncludePath2: incl
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: MKADD_OUT.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenHeapSize: 0x90
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: MKADD_OUT.out
  group (top)
    ./: main.cpp
