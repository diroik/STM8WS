# IAR project Backup (2) of Test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: incl
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Test.sim
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp
